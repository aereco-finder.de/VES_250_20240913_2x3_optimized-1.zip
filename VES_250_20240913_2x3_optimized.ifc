Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VES_250_20240913_2x3.IFC
Time: 2024-09-13T11:44:44
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: T-0000053
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Bereinigungshinweis: Aus; Dateityp: Einzelteil; Erstellt_von: bf; Projektname: Exponat-Marketing-VES_250; Projektnummer: P-00010; Erstellt_am: 30.01.2020; Beschreibung: VES 250; Aenderungsgrund_Anzeige: Aus; Status: Konzeptphase

# IfcBuildingElementProxy: T-0000056
In: Default Storey
Material: PMMA
SolidWorks Custom Properties - Gewicht: 1.679; Material: PMMA; Bereinigungshinweis: Aus; Dateityp: Einzelteil; Erstellt_von: bf; Projektname: Exponat-Marketing-VES_250; Projektnummer: P-00010; Erstellt_am: 06.02.2020; Beschreibung: Scheibe 6mm; Aenderungsgrund_Anzeige: Aus; Status: Konzeptphase

# IfcBuildingElementProxy: T-0000057 (4)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Bereinigungshinweis: Aus; Dateityp: Einzelteil; Erstellt_von: bf; Projektname: Exponat-Marketing-VES_250; Projektnummer: P-00010; Erstellt_am: 06.02.2020; Beschreibung: Winkel; Aenderungsgrund_Anzeige: Aus; Status: Konzeptphase

# IfcElementAssembly: VES_250_20240913_2x3
In: Default Storey
SolidWorks Custom Properties - Gewicht: 1.680; Bereinigungshinweis: Aus; Dateityp: Einzelteil; Erstellt_am: 20.10.2023; Erstellt_von: bf; Projektnummer: P-00009; Projektname: Brandschutz; Beschreibung: VES-250; Aenderungsgrund_Anzeige: Aus; Status: Konzeptphase
